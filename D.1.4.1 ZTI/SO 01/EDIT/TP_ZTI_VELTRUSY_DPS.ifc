Properties of the parts of a building model (IFC4), part 1 of 2

# File
Description: Option [Stavební část: Off], Option [Zdravotní technicka/vytápění: On], Option [Požadavek na prostup: Off]
Time: 2023-09-01T13:43:23
Author: technical-project
Organization: technical-project
Written by: DDS_IFC v3.0
Made in: DDS-CAD Version 17 x64 build 30/7-2022
Authorization: DDS

# IfcSite, par. č. 406/2
Description: Veltrusy; RefLatitude: 50, 5, 0, 0; RefLongitude: 14, 25, 0, 0; RefElevation: 180 m
Pset_LandRegistration - IsPermanentID: no

# IfcBuilding, Budova
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m

# IfcBuildingStorey (7)
In: Budova
Name | Description | Elevation (m)
3.NP | 3.NP | 7.2
Střecha | Střecha | 15
4.NP | 4.NP | 11.1
Stavební část 009 | Stavební část 009 | 18.9
2.NP | 2.NP | 3.3
1.NP | 1.NP | 0
Základy | Základy | -1.9

# IfcCoil: Vyrovnávací zásobník teplé vody 500 litrů, izolovaný, 1
In: 2.NP
Type - PredefinedType: WATERHEATINGCOIL
Type - Pset_ManufacturerTypeInformation - ArticleNumber: 370/500; ModelLabel: Vyrovnávací zásobník teplé vody 500 litrů, izolovaný; Manufacturer: DDS

# IfcDistributionPort (4919)
FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name | NominalDiameter (m)
1927 x  | 0.02
872 x  | 0.1
365 x  | 0.025
792 x  | 0.05
289 x  | 0.07
174 x  | 0.125
40 x  | 0.15
317 x  | 0.032
143 x  | 0.04

# IfcElectricAppliance: Myčka nádobí, 1
In: 1.NP
Type - Pset_ManufacturerTypeInformation - ArticleNumber: WM-20160509-004; ModelLabel: Myčka nádobí; Manufacturer: DDS

# IfcFilter: HT čistící kus se šroubovacím uzávěrem DN 100 (11)
Type - Pset_ManufacturerTypeInformation - ArticleNumber: FLHT061100; ModelLabel: HT čistící kus se šroubovacím uzávěrem DN 100; Manufacturer: DDS
Name | In
2 x 11 | 3.NP
3 x 1 | 2.NP
 | 1.NP
3 x  | 4.NP
-1 | 1.NP
0 | 4.NP

# IfcFireSuppressionTerminal: Hadicový naviják, integrovaný, EN 671-1/R, Design B (4)
Type - Pset_ManufacturerTypeInformation - ArticleNumber: VM160; ModelLabel: Hadicový naviják, integrovaný, EN 671-1/R, Design B; Manufacturer: DDS
Name | In
2 | 2.NP
4 | 4.NP
3 | 3.NP
1 | 1.NP

# IfcPipeFitting: HT Koleno 15° DN 50 (2)
In: 3.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100050015; ModelLabel: HT Koleno 15° DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.21376 rad; BendRadius: 0.03 m
Name
364
161

# IfcPipeFitting: HT Koleno 30° DN 100, 443
In: 1.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100100030; ModelLabel: HT Koleno 30° DN 100; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.523599 rad; BendRadius: 0.06 m

# IfcPipeFitting: HT Koleno 30° DN 50 (2)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100050030; ModelLabel: HT Koleno 30° DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.523599 rad; BendRadius: 0.03 m
Name | In
311 | 4.NP
160 | 3.NP

# IfcPipeFitting: HT Koleno 45° DN 100 (40)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100100045; ModelLabel: HT Koleno 45° DN 100; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.785398 rad; BendRadius: 0.06 m
Name | In
379 | Základy
382 | Základy
368 | Základy
365 | Základy
408 | Základy
3 x 477 | Základy
481 | Základy
432 | Základy
331 | 4.NP
332 | 4.NP
294 | 3.NP
432 | 1.NP
433 | 1.NP
429 | 1.NP
484 | Základy
3 x 485 | Základy
488 | Základy
490 | Základy
2 x 406 | 1.NP
398 | 1.NP
2 x 408 | 1.NP
399 | 1.NP
410 | 1.NP
405 | 1.NP
333 | 4.NP
334 | 4.NP
375 | 4.NP
373 | 4.NP
377 | 4.NP
329 | 3.NP
291 | 3.NP
309 | 4.NP
392 | Základy
395 | Základy

# IfcPipeFitting: HT Koleno 45° DN 125 (3)
In: Základy
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100125045; ModelLabel: HT Koleno 45° DN 125; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.785398 rad; BendRadius: 0.075 m
Name
311
445
422

# IfcPipeFitting: HT Koleno 45° DN 150, 303
In: Základy
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100150045; ModelLabel: HT Koleno 45° DN 150; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.785398 rad; BendRadius: 0.09 m

# IfcPipeFitting: HT Koleno 45° DN 40 (10)
In: 1.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100040045; ModelLabel: HT Koleno 45° DN 40; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.785398 rad; BendRadius: 0.024 m
Name
491
493
2 x 471
2 x 484
2 x 482
2 x 496

# IfcPipeFitting: HT Koleno 45° DN 50 (61)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100050045; ModelLabel: HT Koleno 45° DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.785398 rad; BendRadius: 0.03 m
Name | In
334 | 4.NP
311 | 4.NP
362 | 3.NP
315 | 4.NP
270 | 2.NP
2 x 274 | 2.NP
272 | 2.NP
385 | 4.NP
312 | 4.NP
336 | 4.NP
310 | 4.NP
2 x 318 | 2.NP
2 x 303 | 3.NP
2 x 306 | 3.NP
304 | 3.NP
331 | 2.NP
329 | 2.NP
495 | 1.NP
456 | 1.NP
306 | 2.NP
478 | 1.NP
421 | 1.NP
433 | 1.NP
423 | 1.NP
440 | 1.NP
411 | 1.NP
413 | 1.NP
418 | 1.NP
417 | 1.NP
402 | 1.NP
259 | 2.NP
409 | 1.NP
2 x 403 | 1.NP
404 | 1.NP
407 | 1.NP
2 x 340 | 4.NP
319 | 4.NP
317 | 4.NP
2 x 344 | 4.NP
2 x 342 | 4.NP
2 x 339 | 4.NP
2 x 346 | 4.NP
2 x 309 | 3.NP
162 | 3.NP
313 | 4.NP
331 | 3.NP
361 | 4.NP
360 | 4.NP
357 | 3.NP
353 | 3.NP

# IfcPipeFitting: HT Koleno 45° DN 70 (17)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100075045; ModelLabel: HT Koleno 45° DN 70; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.785398 rad; BendRadius: 0.042 m
Name | In
346 | 4.NP
367 | 4.NP
394 | 4.NP
392 | 4.NP
303 | 3.NP
298 | 3.NP
187 | 3.NP
300 | 3.NP
353 | 3.NP
185 | 3.NP
360 | 3.NP
423 | 3.NP
351 | 3.NP
425 | 3.NP
358 | 3.NP
352 | 3.NP
350 | 3.NP

# IfcPipeFitting: HT Koleno libovolně DN 100, 323
In: 2.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51001000xx; ModelLabel: HT Koleno libovolně DN 100; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.00206013 rad; BendRadius: 0.06 m

# IfcPipeFitting: HT Koleno libovolně DN 100, 318
In: 2.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51001000xx; ModelLabel: HT Koleno libovolně DN 100; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.0150303 rad; BendRadius: 0.06 m

# IfcPipeFitting: HT Koleno libovolně DN 100, 317
In: 2.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51001000xx; ModelLabel: HT Koleno libovolně DN 100; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.0152774 rad; BendRadius: 0.06 m

# IfcPipeFitting: HT Koleno libovolně DN 100, 471
In: 1.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51001000xx; ModelLabel: HT Koleno libovolně DN 100; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.0200013 rad; BendRadius: 0.06 m

# IfcPipeFitting: HT Koleno libovolně DN 100, 366
In: 3.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51001000xx; ModelLabel: HT Koleno libovolně DN 100; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.0202851 rad; BendRadius: 0.06 m

# IfcPipeFitting: HT Koleno libovolně DN 100, 324
In: 2.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51001000xx; ModelLabel: HT Koleno libovolně DN 100; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.0302938 rad; BendRadius: 0.06 m

# IfcPipeFitting: HT Koleno libovolně DN 100, 330
In: 4.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51001000xx; ModelLabel: HT Koleno libovolně DN 100; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.0311092 rad; BendRadius: 0.06 m

# IfcPipeFitting: HT Koleno libovolně DN 100, 305
In: 4.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51001000xx; ModelLabel: HT Koleno libovolně DN 100; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.0312666 rad; BendRadius: 0.06 m

# IfcPipeFitting: HT Koleno libovolně DN 100, 482
In: Základy
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51001000xx; ModelLabel: HT Koleno libovolně DN 100; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.0840588 rad; BendRadius: 0.06 m

# IfcPipeFitting: HT Koleno libovolně DN 100, 383
In: Základy
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51001000xx; ModelLabel: HT Koleno libovolně DN 100; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.09741 rad; BendRadius: 0.06 m

# IfcPipeFitting: HT Koleno libovolně DN 100, 400
In: Základy
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51001000xx; ModelLabel: HT Koleno libovolně DN 100; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.105205 rad; BendRadius: 0.06 m

# IfcPipeFitting: HT Koleno libovolně DN 100, 398
In: Základy
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51001000xx; ModelLabel: HT Koleno libovolně DN 100; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.689772 rad; BendRadius: 0.06 m

# IfcPipeFitting: HT Koleno libovolně DN 100, 442
In: 1.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51001000xx; ModelLabel: HT Koleno libovolně DN 100; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 1.28703 rad; BendRadius: 0.06 m

# IfcPipeFitting: HT Koleno libovolně DN 100, 431
In: Základy
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51001000xx; ModelLabel: HT Koleno libovolně DN 100; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 1.47355 rad; BendRadius: 0.06 m

# IfcPipeFitting: HT Koleno libovolně DN 125, 446
In: Základy
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51001250xx; ModelLabel: HT Koleno libovolně DN 125; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.0150966 rad; BendRadius: 0.075 m

# IfcPipeFitting: HT Koleno libovolně DN 50 (3)
In: 4.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000500xx; ModelLabel: HT Koleno libovolně DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.0160071 rad; BendRadius: 0.03 m
Name
359
350
355

# IfcPipeFitting: HT Koleno libovolně DN 50, 356
In: 4.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000500xx; ModelLabel: HT Koleno libovolně DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.0162619 rad; BendRadius: 0.03 m

# IfcPipeFitting: HT Koleno libovolně DN 50, 278
In: 2.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000500xx; ModelLabel: HT Koleno libovolně DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.0237197 rad; BendRadius: 0.03 m

# IfcPipeFitting: HT Koleno libovolně DN 50, 311
In: 2.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000500xx; ModelLabel: HT Koleno libovolně DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.0304854 rad; BendRadius: 0.03 m

# IfcPipeFitting: HT Koleno libovolně DN 50, 367
In: 4.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000500xx; ModelLabel: HT Koleno libovolně DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.0304995 rad; BendRadius: 0.03 m

# IfcPipeFitting: HT Koleno libovolně DN 50, 366
In: 3.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000500xx; ModelLabel: HT Koleno libovolně DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.0312139 rad; BendRadius: 0.03 m

# IfcPipeFitting: HT Koleno libovolně DN 50 (2)
In: 4.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000500xx; ModelLabel: HT Koleno libovolně DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.034274 rad; BendRadius: 0.03 m
Name
356
351

# IfcPipeFitting: HT Koleno libovolně DN 50, 360
In: 4.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000500xx; ModelLabel: HT Koleno libovolně DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.034276 rad; BendRadius: 0.03 m

# IfcPipeFitting: HT Koleno libovolně DN 50, 357
In: 4.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000500xx; ModelLabel: HT Koleno libovolně DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.0343937 rad; BendRadius: 0.03 m

# IfcPipeFitting: HT Koleno libovolně DN 50, 312
In: 2.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000500xx; ModelLabel: HT Koleno libovolně DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.0347782 rad; BendRadius: 0.03 m

# IfcPipeFitting: HT Koleno libovolně DN 50, 389
In: 4.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000500xx; ModelLabel: HT Koleno libovolně DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.038204 rad; BendRadius: 0.03 m

# IfcPipeFitting: HT Koleno libovolně DN 50, 335
In: 4.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000500xx; ModelLabel: HT Koleno libovolně DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.32457 rad; BendRadius: 0.03 m

# IfcPipeFitting: HT Koleno libovolně DN 50, 321
In: 2.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000500xx; ModelLabel: HT Koleno libovolně DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.690002 rad; BendRadius: 0.03 m

# IfcPipeFitting: HT Koleno libovolně DN 50, 313
In: 2.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000500xx; ModelLabel: HT Koleno libovolně DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.690427 rad; BendRadius: 0.03 m

# IfcPipeFitting: HT Koleno libovolně DN 50, 367
In: 4.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000500xx; ModelLabel: HT Koleno libovolně DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.692806 rad; BendRadius: 0.03 m

# IfcPipeFitting: HT Koleno libovolně DN 50, 313
In: 3.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000500xx; ModelLabel: HT Koleno libovolně DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.716312 rad; BendRadius: 0.03 m

# IfcPipeFitting: HT Koleno libovolně DN 50, 334
In: 4.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000500xx; ModelLabel: HT Koleno libovolně DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.898041 rad; BendRadius: 0.03 m

# IfcPipeFitting: HT Koleno libovolně DN 70, 370
In: 4.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000750xx; ModelLabel: HT Koleno libovolně DN 70; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.00876533 rad; BendRadius: 0.042 m

# IfcPipeFitting: HT Koleno libovolně DN 70, 470
In: 1.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000750xx; ModelLabel: HT Koleno libovolně DN 70; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.0200013 rad; BendRadius: 0.042 m

# IfcPipeFitting: HT Koleno libovolně DN 70, 347
In: 4.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000750xx; ModelLabel: HT Koleno libovolně DN 70; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.0218723 rad; BendRadius: 0.042 m

# IfcPipeFitting: HT Koleno libovolně DN 70, 369
In: 4.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000750xx; ModelLabel: HT Koleno libovolně DN 70; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.630405 rad; BendRadius: 0.042 m

# IfcPipeFitting: HT Koleno libovolně DN 70, 338
In: 4.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE51000750xx; ModelLabel: HT Koleno libovolně DN 70; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 1.25064 rad; BendRadius: 0.042 m

# IfcPipeFitting: HT T-kus 45° 100x100 (10)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-040; ModelLabel: HT T-kus 45° 100x100; Manufacturer: DDS
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
95 | 4.NP
183 | Základy
179 | Základy
150 | 1.NP
182 | Základy
148 | 1.NP
159 | 1.NP
152 | 1.NP
94 | 4.NP
78 | 4.NP

# IfcPipeFitting: HT T-kus 45° 100x50 (7)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-034; ModelLabel: HT T-kus 45° 100x50; Manufacturer: DDS
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
112 | 2.NP
156 | 4.NP
164 | 1.NP
165 | 1.NP
111 | 2.NP
110 | 3.NP
117 | 3.NP

# IfcPipeFitting: HT T-kus 45° 125x100 (3)
In: 3.NP
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-052; ModelLabel: HT T-kus 45° 125x100; Manufacturer: DDS
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name
112
80
87

# IfcPipeFitting: HT T-kus 45° 125x125, 159
In: Základy
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-055; ModelLabel: HT T-kus 45° 125x125; Manufacturer: DDS
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE

# IfcPipeFitting: HT T-kus 45° 150x100 (2)
In: Základy
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-064; ModelLabel: HT T-kus 45° 150x100; Manufacturer: DDS
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name
160
157

# IfcPipeFitting: HT T-kus 45° 50x50 (7)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-010; ModelLabel: HT T-kus 45° 50x50; Manufacturer: DDS
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
95 | 4.NP
2 x 167 | 1.NP
112 | 1.NP
92 | 4.NP
93 | 4.NP
80 | 4.NP

# IfcPipeFitting: HT T-kus 45° 70x50 (12)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-016; ModelLabel: HT T-kus 45° 70x50; Manufacturer: DDS
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
96 | 4.NP
98 | 4.NP
97 | 4.NP
2 x 167 | 1.NP
168 | 1.NP
113 | 1.NP
94 | 4.NP
90 | 3.NP
147 | 3.NP
81 | 4.NP
157 | 4.NP

# IfcPipeFitting: HT T-kus 87,5° 100x100 (14)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-042; ModelLabel: HT T-kus 87,5° 100x100; Manufacturer: DDS
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
158 | 2.NP
112 | 3.NP
151 | 1.NP
152 | 1.NP
2 x 163 | 1.NP
149 | 1.NP
90 | 4.NP
2 x 147 | 3.NP
93 | 4.NP
88 | 4.NP
155 | 4.NP
76 | 4.NP

# IfcPipeFitting: HT T-kus 87,5° 100x50 (6)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-036; ModelLabel: HT T-kus 87,5° 100x50; Manufacturer: DDS
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
111 | 3.NP
163 | 1.NP
133 | 2.NP
111 | 2.NP
154 | 4.NP
119 | 3.NP

# IfcPipeFitting: HT T-kus 87,5° 100x70 (12)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-039; ModelLabel: HT T-kus 87,5° 100x70; Manufacturer: DDS
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
163 | 4.NP
148 | 1.NP
166 | 1.NP
90 | 4.NP
149 | 1.NP
111 | 3.NP
164 | 3.NP
78 | 4.NP
155 | 2.NP
94 | 4.NP
2 x 164 | 4.NP

# IfcPipeFitting: HT T-kus 87,5° 70x50, 155
In: 4.NP
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-018; ModelLabel: HT T-kus 87,5° 70x50; Manufacturer: DDS
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE

# IfcPipeFitting: HT koleno 100/87° (41)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100100090; ModelLabel: HT koleno 100/87°; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 1.5708 rad; BendRadius: 0.06 m
Name | In
366 | Základy
2 x 483 | Základy
379 | Základy
365 | Základy
489 | Základy
491 | Základy
321 | Základy
411 | Základy
397 | Základy
326 | 2.NP
429 | Základy
486 | Základy
2 x 280 | 2.NP
333 | 4.NP
396 | Základy
325 | 2.NP
2 x 313 | 3.NP
279 | 2.NP
2 x 407 | 1.NP
400 | 1.NP
411 | 1.NP
409 | 1.NP
435 | 1.NP
436 | 1.NP
335 | 4.NP
374 | 4.NP
378 | 4.NP
376 | 4.NP
307 | Základy
372 | Základy
327 | 2.NP
392 | Základy
332 | 3.NP
370 | 3.NP
295 | 3.NP
297 | 3.NP
310 | 4.NP

# IfcPipeFitting: HT koleno 125/87° (12)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100125090; ModelLabel: HT koleno 125/87°; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 1.5708 rad; BendRadius: 0.075 m
Name | In
411 | Základy
425 | Základy
2 x 308 | Základy
316 | 3.NP
319 | 3.NP
414 | Základy
381 | 3.NP
369 | 3.NP
408 | Základy
307 | Základy
309 | Základy

# IfcPipeFitting: HT koleno 40/87° (2)
In: 1.NP
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100040090; ModelLabel: HT koleno 40/87°; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 1.5708 rad; BendRadius: 0.024 m
Name
481
502

# IfcPipeFitting: HT koleno 50/87° (59)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100050090; ModelLabel: HT koleno 50/87°; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 1.5508 rad; BendRadius: 0.03 m
Name | In
314 | 4.NP
353 | 3.NP
312 | 4.NP
335 | 4.NP
359 | 3.NP
317 | 3.NP
268 | 2.NP
388 | 4.NP
310 | 4.NP
309 | 4.NP
320 | 2.NP
318 | 2.NP
301 | 3.NP
308 | 3.NP
2 x 305 | 3.NP
313 | 2.NP
454 | 1.NP
493 | 1.NP
431 | 1.NP
476 | 1.NP
422 | 1.NP
424 | 1.NP
419 | 1.NP
412 | 1.NP
414 | 1.NP
410 | 1.NP
404 | 1.NP
400 | 1.NP
405 | 1.NP
408 | 1.NP
308 | 2.NP
259 | 2.NP
316 | 4.NP
318 | 4.NP
320 | 4.NP
2 x 341 | 4.NP
2 x 345 | 4.NP
2 x 347 | 4.NP
2 x 343 | 4.NP
277 | 2.NP
274 | 2.NP
365 | 4.NP
366 | 4.NP
309 | 3.NP
312 | 3.NP
430 | 3.NP
364 | 3.NP
368 | 4.NP
361 | 4.NP
355 | 4.NP
358 | 4.NP
352 | 4.NP
362 | 4.NP
332 | 3.NP

# IfcPipeFitting: HT koleno 70/87° (10)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100075090; ModelLabel: HT koleno 70/87°; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 1.5708 rad; BendRadius: 0.042 m
Name | In
311 | 2.NP
348 | 4.NP
370 | 4.NP
395 | 4.NP
306 | 3.NP
342 | 3.NP
437 | 1.NP
442 | 1.NP
415 | 1.NP
401 | 1.NP

# IfcPipeFitting: HT redukce DN 100/50 (3)
Type - PredefinedType: TRANSITION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH5100100050; ModelLabel: HT redukce DN 100/50; Manufacturer: DDS
Name | In
6 | 4.NP
5 | 3.NP
7 | 2.NP

# IfcPipeFitting: HT redukce DN 100/70 (7)
Type - PredefinedType: TRANSITION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH5100100075; ModelLabel: HT redukce DN 100/70; Manufacturer: DDS
Name | In
11 | Základy
12 | Základy
10 | Základy
9 | Základy
11 | 3.NP
6 | 3.NP
3 | 4.NP

# IfcPipeFitting: HT redukce DN 125/100, 7
In: 3.NP
Type - PredefinedType: TRANSITION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH5100125100; ModelLabel: HT redukce DN 125/100; Manufacturer: DDS

# IfcPipeFitting: HT redukce DN 150/100 (2)
In: Základy
Type - PredefinedType: TRANSITION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH-20140925-004; ModelLabel: HT redukce DN 150/100; Manufacturer: DDS
Name
10
11

# IfcPipeFitting: HT redukce DN 70/50 (10)
Type - PredefinedType: TRANSITION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH5100075050; ModelLabel: HT redukce DN 70/50; Manufacturer: DDS
Name | In
2 x 8 | 4.NP
7 | 4.NP
10 | 1.NP
9 | 1.NP
8 | 1.NP
10 | 3.NP
8 | 3.NP
9 | 3.NP
9 | 4.NP

# IfcPipeFitting: HT redukce DN libovolná (3)
Type - PredefinedType: TRANSITION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH5100xxx; ModelLabel: HT redukce DN libovolná; Manufacturer: DDS
Name | In
3 | 4.NP
14 | 1.NP
13 | 1.NP

# IfcPipeFitting: KG T-kus 45° 100x100 (2)
In: Základy
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121204-001; ModelLabel: KG T-kus 45° 100x100; Manufacturer: DDS
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name
178
179

# IfcPipeFitting: KG T-kus 45° 150x100 (4)
In: Základy
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121204-007; ModelLabel: KG T-kus 45° 150x100; Manufacturer: DDS
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name
163
165
154
166

# IfcPipeFitting: KG koleno 45° DN 100, 310
In: Základy
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5200100045; ModelLabel: KG koleno 45° DN 100; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.804037 rad; BendRadius: 0.06 m

# IfcPipeFitting: KG koleno 45° DN 150, 371
In: Základy
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5200150045; ModelLabel: KG koleno 45° DN 150; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.785398 rad; BendRadius: 0.09 m

# IfcPipeFitting: Koleno 90° (266)
Type - PredefinedType: BEND; Material: layer 0 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-K-FBP-82; ModelLabel: Koleno 90°; Manufacturer: Ekoplastik
Type - Pset_PipeFittingTypeBend - BendAngle: 1.5708 rad; BendRadius: 0.0268 m
Name | In
2 x 325 | 3.NP
5 x 420 | 1.NP
3 x 419 | 1.NP
298 | 3.NP
327 | 3.NP
336 | 2.NP
398 | 3.NP
366 | 3.NP
3 x 360 | 3.NP
363 | 3.NP
367 | 3.NP
2 x 361 | 3.NP
2 x 450 | 1.NP
365 | 3.NP
369 | 3.NP
272 | 2.NP
338 | 3.NP
339 | 3.NP
504 | 1.NP
187 | 3.NP
502 | 1.NP
377 | 3.NP
385 | 3.NP
359 | 3.NP
263 | 3.NP
188 | 3.NP
259 | 3.NP
362 | 3.NP
349 | 3.NP
407 | 3.NP
262 | 3.NP
404 | 3.NP
6 x 268 | 2.NP
270 | 2.NP
327 | 4.NP
331 | 4.NP
421 | 1.NP
388 | 4.NP
318 | 4.NP
383 | 4.NP
321 | 4.NP
390 | 4.NP
322 | 4.NP
278 | 2.NP
2 x 320 | 4.NP
324 | 4.NP
2 x 323 | 4.NP
2 x 313 | 4.NP
317 | 4.NP
3 x 336 | 4.NP
3 x 338 | 4.NP
273 | 2.NP
2 x 328 | 3.NP
441 | 1.NP
329 | 3.NP
2 x 399 | 1.NP
434 | 1.NP
437 | 1.NP
334 | 2.NP
417 | 3.NP
415 | 3.NP
431 | 3.NP
2 x 406 | 1.NP
404 | 1.NP
253 | 2.NP
312 | 2.NP
427 | 1.NP
4 x 286 | 3.NP
2 x 290 | 3.NP
284 | 2.NP
309 | 2.NP
2 x 306 | 2.NP
283 | 2.NP
3 x 257 | 2.NP
259 | 2.NP
3 x 255 | 2.NP
304 | 2.NP
429 | 1.NP
2 x 314 | 3.NP
307 | 3.NP
422 | 1.NP
2 x 401 | 1.NP
403 | 1.NP
2 x 402 | 1.NP
408 | 1.NP
405 | 1.NP
409 | 1.NP
407 | 1.NP
3 x 411 | 1.NP
470 | 1.NP
472 | 1.NP
418 | 1.NP
2 x 456 | 1.NP
445 | 1.NP
457 | 1.NP
2 x 487 | 1.NP
494 | 1.NP
2 x 454 | 1.NP
3 x 493 | 1.NP
399 | 2.NP
259 | 1.NP
283 | 1.NP
306 | 3.NP
3 x 325 | 4.NP
278 | 4.NP
275 | 4.NP
270 | 4.NP
271 | 4.NP
269 | 4.NP
277 | 4.NP
294 | 4.NP
3 x 503 | 1.NP
2 x 286 | 4.NP
288 | 4.NP
285 | 4.NP
295 | 4.NP
293 | 4.NP
2 x 297 | 4.NP
300 | 4.NP
3 x 289 | 4.NP
3 x 512 | 1.NP
3 x 301 | 4.NP
299 | 4.NP
3 x 312 | 4.NP
387 | 4.NP
309 | 4.NP
397 | 2.NP
386 | 4.NP
2 x 314 | 4.NP
4 x 316 | 4.NP
2 x 332 | 4.NP
298 | 4.NP
477 | 1.NP
328 | 4.NP
475 | 1.NP
479 | 1.NP
474 | 1.NP
317 | 3.NP
6 x 462 | 1.NP
3 x 483 | 1.NP
478 | 1.NP
486 | 1.NP
309 | 3.NP
471 | 1.NP
283 | 3.NP
2 x 279 | 3.NP
323 | 3.NP
316 | 3.NP
281 | 3.NP
295 | 3.NP
299 | 3.NP
294 | 3.NP
346 | 3.NP
344 | 3.NP
296 | 3.NP
390 | 3.NP
258 | 3.NP
358 | 3.NP
337 | 3.NP
375 | 3.NP
304 | 3.NP
335 | 4.NP
341 | 4.NP
342 | 4.NP
124 | 4.NP
2 x 214 | 4.NP
218 | 4.NP
2 x 215 | 4.NP
290 | 4.NP
2 x 276 | 4.NP
254 | 4.NP
329 | 4.NP
367 | 4.NP
366 | 4.NP
257 | 4.NP
302 | 4.NP
305 | 4.NP
259 | 4.NP
304 | 4.NP
315 | 4.NP
2 x 351 | 3.NP
217 | 4.NP
2 x 453 | 1.NP
353 | 3.NP
123 | 4.NP
455 | 1.NP
219 | 4.NP
451 | 1.NP
216 | 4.NP

# IfcPipeFitting: Koleno 90° (37)
Type - PredefinedType: BEND; Material: layer 0 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-K-FBP-83; ModelLabel: Koleno 90°; Manufacturer: Ekoplastik
Type - Pset_PipeFittingTypeBend - BendAngle: 1.5708 rad; BendRadius: 0.031 m
Name | In
335 | 3.NP
4 x 502 | 1.NP
4 x 452 | 1.NP
2 x 429 | 1.NP
296 | 2.NP
413 | 1.NP
304 | 3.NP
400 | 1.NP
2 x 412 | 1.NP
401 | 1.NP
2 x 395 | 1.NP
308 | 2.NP
304 | 2.NP
307 | 2.NP
285 | 4.NP
450 | 1.NP
403 | 1.NP
284 | 4.NP
310 | 3.NP
299 | 3.NP
3 x 303 | 4.NP
330 | 4.NP
328 | 4.NP
310 | 4.NP
312 | 3.NP
301 | 3.NP

# IfcPipeFitting: Koleno 90° (43)
Type - PredefinedType: BEND; Material: layer 0 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-K-FBP-84; ModelLabel: Koleno 90°; Manufacturer: Ekoplastik
Type - Pset_PipeFittingTypeBend - BendAngle: 1.5708 rad; BendRadius: 0.0365 m
Name | In
3 x 396 | 2.NP
402 | 2.NP
389 | 2.NP
300 | 2.NP
289 | 2.NP
2 x 396 | 4.NP
2 x 395 | 4.NP
394 | 4.NP
397 | 4.NP
312 | 3.NP
307 | 3.NP
313 | 3.NP
305 | 3.NP
405 | 3.NP
2 x 402 | 3.NP
395 | 3.NP
409 | 3.NP
284 | 2.NP
323 | 2.NP
325 | 2.NP
424 | 1.NP
397 | 2.NP
328 | 2.NP
354 | 1.NP
353 | 1.NP
2 x 350 | 1.NP
338 | 1.NP
293 | 1.NP
256 | 1.NP
257 | 1.NP
301 | 2.NP
401 | 2.NP
393 | 4.NP
2 x 394 | 2.NP
324 | 2.NP
409 | 1.NP

# IfcPipeFitting: Koleno 90° (11)
Type - PredefinedType: BEND; Material: layer 0 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-K-FBP-85; ModelLabel: Koleno 90°; Manufacturer: Ekoplastik
Type - Pset_PipeFittingTypeBend - BendAngle: 1.5708 rad; BendRadius: 0.043 m
Name | In
395 | 3.NP
405 | 1.NP
319 | 1.NP
412 | 1.NP
410 | 1.NP
313 | 1.NP
2 x 315 | 1.NP
403 | 1.NP
309 | 1.NP
307 | 1.NP

# IfcPipeFitting: Koleno, kompresní kroužek, červená mosaz xx° 20 x 1,9, 419
In: 1.NP
Type - PredefinedType: BEND; Material: layer 0 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE-230719-006; ModelLabel: Koleno, kompresní kroužek, červená mosaz xx° 20 x 1,9; Manufacturer: DDS
Type - Pset_PipeFittingTypeBend - BendAngle: 0.0188048 rad; BendRadius: 0.0225 m

# IfcPipeFitting: Redukce (8)
Type - PredefinedType: TRANSITION; Material: layer 0 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-R-FBP-247; ModelLabel: Redukce; Manufacturer: Ekoplastik
Name | In
11 | 1.NP
12 | 2.NP
24 | 2.NP
13 | 4.NP
10 | 4.NP
13 | 2.NP
10 | 3.NP
5 | 4.NP

# IfcPipeFitting: Redukce (2)
In: 2.NP
Type - PredefinedType: TRANSITION; Material: layer 0 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-R-FBP-248; ModelLabel: Redukce; Manufacturer: Ekoplastik
Name
26
12

# IfcPipeFitting: Redukce (3)
Type - PredefinedType: TRANSITION; Material: layer 0 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-R-FBP-249; ModelLabel: Redukce; Manufacturer: Ekoplastik
Name | In
8 | 1.NP
23 | 2.NP
27 | 2.NP

# IfcPipeFitting: Redukce, 8
In: 1.NP
Type - PredefinedType: TRANSITION; Material: layer 0 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-R-FBP-256; ModelLabel: Redukce; Manufacturer: Ekoplastik

# IfcPipeFitting: T-kus (68)
Type - PredefinedType: JUNCTION; Material: layer 0 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-T-FBP-165; ModelLabel: T-kus; Manufacturer: Ekoplastik
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
2 x 113 | 2.NP
111 | 3.NP
119 | 1.NP
117 | 1.NP
2 x 150 | 3.NP
2 x 118 | 1.NP
128 | 1.NP
102 | 2.NP
127 | 1.NP
2 x 140 | 1.NP
99 | 3.NP
139 | 1.NP
116 | 3.NP
126 | 1.NP
157 | 3.NP
156 | 3.NP
100 | 3.NP
3 x 154 | 4.NP
151 | 3.NP
147 | 3.NP
154 | 2.NP
155 | 2.NP
2 x 112 | 2.NP
92 | 2.NP
94 | 2.NP
116 | 1.NP
137 | 1.NP
115 | 1.NP
130 | 1.NP
134 | 1.NP
122 | 1.NP
121 | 1.NP
136 | 1.NP
124 | 1.NP
169 | 1.NP
2 x 110 | 3.NP
119 | 4.NP
2 x 128 | 4.NP
2 x 129 | 4.NP
147 | 4.NP
158 | 4.NP
107 | 3.NP
115 | 3.NP
155 | 4.NP
135 | 1.NP
133 | 1.NP
112 | 4.NP
113 | 4.NP
91 | 4.NP
103 | 4.NP
90 | 4.NP
96 | 4.NP
110 | 4.NP
111 | 4.NP
156 | 4.NP
134 | 4.NP
143 | 4.NP
127 | 4.NP

# IfcPipeFitting: T-kus (9)
Type - PredefinedType: JUNCTION; Material: layer 0 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-T-FBP-166; ModelLabel: T-kus; Manufacturer: Ekoplastik
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
160 | 1.NP
90 | 2.NP
110 | 2.NP
113 | 2.NP
112 | 2.NP
108 | 3.NP
132 | 4.NP
136 | 4.NP
109 | 3.NP

# IfcPipeFitting: T-kus (6)
Type - PredefinedType: JUNCTION; Material: layer 0 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-T-FBP-167; ModelLabel: T-kus; Manufacturer: Ekoplastik
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
90 | 2.NP
162 | 3.NP
132 | 2.NP
92 | 2.NP
150 | 1.NP
115 | 1.NP

# IfcPipeFitting: T-kus, 158
In: 1.NP
Type - PredefinedType: JUNCTION; Material: layer 0 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-T-FBP-168; ModelLabel: T-kus; Manufacturer: Ekoplastik
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE

# IfcPipeFitting: T-kus (11)
Type - PredefinedType: JUNCTION; Material: layer 0 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-T-FBP-176; ModelLabel: T-kus; Manufacturer: Ekoplastik
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
114 | 2.NP
165 | 1.NP
130 | 1.NP
126 | 1.NP
129 | 1.NP
115 | 1.NP
124 | 4.NP
123 | 4.NP
114 | 4.NP
113 | 4.NP
112 | 3.NP

# IfcPipeFitting: T-kus (4)
Type - PredefinedType: JUNCTION; Material: layer 0 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-T-FBP-177; ModelLabel: T-kus; Manufacturer: Ekoplastik
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
117 | 1.NP
154 | 1.NP
80 | 1.NP
110 | 2.NP

# IfcPipeFitting: T-kus (2)
Type - PredefinedType: JUNCTION; Material: layer 0 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-T-FBP-178; ModelLabel: T-kus; Manufacturer: Ekoplastik
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
162 | 1.NP
154 | 4.NP

# IfcPipeFitting: T-kus (2)
Type - PredefinedType: JUNCTION; Material: layer 0 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-T-FBP-181; ModelLabel: T-kus; Manufacturer: Ekoplastik
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
155 | 1.NP
111 | 2.NP

# IfcPipeFitting: T-kus (3)
In: 4.NP
Type - PredefinedType: JUNCTION; Material: layer 0 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-T-FBP-189; ModelLabel: T-kus; Manufacturer: Ekoplastik
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name
109
127
112

# IfcPipeFitting: T-kus (2)
Type - PredefinedType: JUNCTION; Material: layer 0 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-T-FBP-191; ModelLabel: T-kus; Manufacturer: Ekoplastik
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
130 | 2.NP
69 | 4.NP

# IfcPipeSegment: Fiber Basalt Plus, 757
In: 4.NP
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.0028 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-Fib-24; ModelLabel: Fiber Basalt Plus; Manufacturer: Ekoplastik
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.02 m; InnerDiameter: 0.0144 m; OuterDiameter: 0.02 m
Qto_PipeSegmentBaseQuantities - Length: 0 m

# IfcPipeSegment: Fiber Basalt Plus (552)
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.0028 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-Fib-24; ModelLabel: Fiber Basalt Plus; Manufacturer: Ekoplastik
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.02 m; InnerDiameter: 0.0144 m; OuterDiameter: 0.02 m
Name | In | Length (m)
906 | 1.NP | 0.126449
878 | 1.NP | 0.0725117
835 | 1.NP | 0.0392
836 | 1.NP | 0.0883158
883 | 1.NP | 0.0725117
876 | 3.NP | 0.126449
873 | 1.NP | 0.0726821
129 | 3.NP | 0.0557014
20 | 2.NP | 0
1248 | 2.NP | 0.3712
128 | 3.NP | 2.98946
2 x 838 | 1.NP | 0.646
837 | 1.NP | 1.8464
19 | 2.NP | 0.208147
884 | 1.NP | 0.1067
879 | 1.NP | 0.1162
1172 | 3.NP | 0.0042
1802 | 3.NP | 0.096
1129 | 3.NP | 0.0128621
1248 | 3.NP | 6.41646
869 | 1.NP | 0.1162
838 | 1.NP | 0.6462
60 | 3.NP | 0.330962
6 | 3.NP | 0.4232
781 | 2.NP | 0.0272418
9 | 2.NP | 3.9
1249 | 3.NP | 3.57683
20 | 2.NP | 1.09635
1250 | 3.NP | 0.494032
868 | 1.NP | 0.0726821
6 | 3.NP | 0.127594
1215 | 3.NP | 0.0227117
874 | 1.NP | 0.1162
1164 | 3.NP | 0.56883
838 | 1.NP | 0.442848
838 | 1.NP | 0.0097
1150 | 3.NP | 0.031235
1228 | 2.NP | 2.246
1172 | 3.NP | 3.59335
1216 | 3.NP | 0.0462
1179 | 1.NP | 0.828962
1228 | 2.NP | 0.123
1135 | 1.NP | 0.531241
1226 | 3.NP | 0.0462
1225 | 3.NP | 1.10259e-14
61 | 3.NP | 2.83084
1802 | 3.NP | 0.523
789 | 2.NP | 0.0329467
1228 | 2.NP | 1.423
1179 | 1.NP | 0.421136
298 | 3.NP | 0.0464022
2 x 1135 | 1.NP | 0.646
871 | 2.NP | 3.523
1392 | 3.NP | 3.93572
298 | 3.NP | 3.79623
1802 | 3.NP | 2.6962
1247 | 2.NP | 0.5164
1179 | 1.NP | 0.0042
199 | 3.NP | 3.80971
1395 | 3.NP | 2.6962
1135 | 1.NP | 0.209215
154 | 3.NP | 3.4232
1210 | 3.NP | 0.3232
2777 | 3.NP | 0.8532
74 | 3.NP | 0.2232
418 | 3.NP | 0.3232
1179 | 1.NP | 0.820244
1211 | 3.NP | 0.266822
2773 | 3.NP | 0.0461125
418 | 3.NP | 0.179876
2777 | 3.NP | 0.0461125
1395 | 3.NP | 0.0097
684 | 3.NP | 0.0535422
1211 | 3.NP | 0.149915
437 | 3.NP | 0.0462022
684 | 3.NP | 0.0353311
2773 | 3.NP | 0.8532
1395 | 3.NP | 0.673
418 | 3.NP | 0.133565
504 | 3.NP | 0.0232
815 | 3.NP | 0.0422
1380 | 3.NP | 2.7962
792 | 3.NP | 0.573
792 | 3.NP | 2.7962
792 | 3.NP | 3.93266
1380 | 3.NP | 0.673
792 | 3.NP | 0.046
29 | 2.NP | 0.0764
30 | 2.NP | 0.255656
35 | 2.NP | 1.0964
28 | 2.NP | 0.2732
36 | 2.NP | 0.0804558
932 | 4.NP | 0.4462
737 | 4.NP | 0.2222
744 | 4.NP | 0.133743
755 | 4.NP | 0.0337428
216 | 4.NP | 2.76983
91 | 4.NP | 0.0732
217 | 4.NP | 0.386187
932 | 4.NP | 0.0343255
773 | 4.NP | 0.133543
974 | 4.NP | 0.2464
188 | 4.NP | 1.8464
189 | 4.NP | 0.100271
973 | 4.NP | -6.93889e-17
973 | 4.NP | 1.42302
154 | 3.NP | 3.86321
978 | 4.NP | 0.0597827
218 | 4.NP | 0
939 | 4.NP | 1.35954
939 | 4.NP | 0.136154
940 | 4.NP | 0.24161
974 | 4.NP | 0.529815
944 | 4.NP | 0.00455434
904 | 4.NP | 0.148884
915 | 4.NP | -0.0127134
940 | 4.NP | 0.2464
375 | 2.NP | 0.22
903 | 4.NP | 1.11022e-15
916 | 4.NP | 0.221014
1380 | 3.NP | 0.0097
1166 | 2.NP | 0.0231
1097 | 4.NP | 0.132898
1106 | 4.NP | 1.1964
1132 | 2.NP | 0.144015
1098 | 4.NP | 4.85723e-17
1105 | 4.NP | 0.00186875
1107 | 4.NP | 0.134867
519 | 3.NP | 0.0232
862 | 3.NP | 0.0692316
1132 | 2.NP | 0.3232
862 | 3.NP | 0.0269276
507 | 3.NP | 0.1264
876 | 3.NP | 0.1232
862 | 3.NP | 0.2232
876 | 3.NP | 0.0676336
928 | 1.NP | 0.0122122
995 | 1.NP | 0.0732
966 | 1.NP | 14.5451
1244 | 2.NP | 0.0232
1197 | 3.NP | 14.6191
964 | 1.NP | 0.0732
986 | 1.NP | 0.0155459
987 | 1.NP | 2.0462
205 | 3.NP | -5.20417e-17
921 | 1.NP | 0.598694
928 | 1.NP | 2.2164
206 | 3.NP | 4.19623
965 | 1.NP | 3.89874
580 | 3.NP | 0.2832
1197 | 3.NP | 2.19097
580 | 3.NP | 0.149963
994 | 1.NP | 0.238006
1015 | 3.NP | 0.0232
580 | 3.NP | 0.163479
603 | 3.NP | 2.19117
602 | 3.NP | 0.0864022
745 | 2.NP | 3.123
1132 | 2.NP | 0.0754886
745 | 2.NP | 0.623
907 | 1.NP | 5.86887
745 | 2.NP | 0.046
1900 | 3.NP | 0.0968368
1896 | 3.NP | 0.522037
1895 | 3.NP | 0.2764
1899 | 3.NP | 1.0964
805 | 3.NP | 0.032619
797 | 3.NP | 3.58079e-15
987 | 3.NP | 0.1
1191 | 2.NP | 0.262694
1191 | 2.NP | 3.89961
1191 | 2.NP | 0.1
1416 | 2.NP | 0.787616
1421 | 2.NP | 4.31964
1415 | 2.NP | 1.249e-16
2821 | 2.NP | 0.1232
686 | 2.NP | 0
114 | 2.NP | 0.3712
1421 | 2.NP | 0.560116
1407 | 2.NP | 0.0232
158 | 2.NP | 0.0462
114 | 2.NP | 1.846
1298 | 2.NP | 0.0464
711 | 2.NP | 0.323
711 | 2.NP | 0.344368
158 | 2.NP | 2.546
158 | 2.NP | 0.523
1889 | 2.NP | 0.5164
114 | 2.NP | 0.523
1410 | 2.NP | 0.1764
1411 | 2.NP | 0.3714
1389 | 2.NP | 0.0232
1886 | 2.NP | 0.0232
1420 | 2.NP | 0.0151333
1392 | 2.NP | 0.5164
920 | 1.NP | 2.55191
1393 | 2.NP | 0.3617
1435 | 2.NP | 0.0232
1439 | 2.NP | 4.10305
813 | 1.NP | 0.0117742
894 | 1.NP | 0.0421655
812 | 1.NP | 0.0442
1438 | 2.NP | 1.00275
1439 | 2.NP | 0.574705
813 | 1.NP | 0.124139
814 | 1.NP | 1.8964
908 | 1.NP | 0.0247337
903 | 1.NP | 0.0662
909 | 1.NP | 0.0662
902 | 1.NP | 0.0245633
889 | 1.NP | 0.0245633
914 | 1.NP | 0.0247337
950 | 1.NP | 0.0464
812 | 1.NP | 0.646
951 | 1.NP | 0.169652
970 | 1.NP | 0.816936
881 | 1.NP | 0.0445789
949 | 1.NP | 0.640049
881 | 1.NP | 2.16702
949 | 1.NP | 0.810826
830 | 1.NP | 0.3212
831 | 1.NP | 0.646
969 | 1.NP | 0.2232
919 | 1.NP | 0.0851282
915 | 1.NP | 0.0662
879 | 1.NP | 0.012071
812 | 1.NP | 0.0664
877 | 1.NP | 1.12583
812 | 1.NP | 0.6462
918 | 1.NP | 0.0463985
970 | 1.NP | 4.44526
890 | 1.NP | 0.195095
890 | 1.NP | 0.646201
890 | 1.NP | 0.0164
890 | 1.NP | 0.646001
952 | 1.NP | 1.8464
1028 | 1.NP | 0.355923
1028 | 1.NP | 0.6462
1028 | 1.NP | 0.646
963 | 1.NP | 0.413356
1046 | 1.NP | 0.0261801
964 | 1.NP | 0.156729
965 | 1.NP | 1.94954
1028 | 1.NP | 0.0164
849 | 1.NP | 0.0162771
963 | 1.NP | 0.001
963 | 1.NP | 0.26895
879 | 1.NP | 2.2164
878 | 1.NP | 0.872245
773 | 2.NP | 0.343958
877 | 1.NP | 1.48746
624 | 1.NP | 0.13045
624 | 1.NP | 0.272196
213 | 1.NP | 0.321225
213 | 1.NP | 0.37333
1325 | 1.NP | 0.0097
213 | 1.NP | 0.0911197
772 | 2.NP | 0.0764
1325 | 1.NP | 0.373214
1225 | 3.NP | 0.673
18 | 2.NP | 0.1764
876 | 1.NP | 5.94232
1884 | 2.NP | 0.3642
17 | 2.NP | 0.2732
37 | 4.NP | 0.923845
1883 | 2.NP | 0.5164
36 | 4.NP | 1.0964
324 | 4.NP | 0.0445096
330 | 4.NP | 0.0445096
366 | 4.NP | 0.0445096
331 | 4.NP | 0.4162
46 | 4.NP | 1.50139
367 | 4.NP | 0.4122
318 | 4.NP | 0.0446799
319 | 4.NP | 0.4162
376 | 4.NP | 0.304344
376 | 4.NP | 0.0042
381 | 4.NP | 0.0445096
358 | 4.NP | 0.29148
382 | 4.NP | 0.4122
325 | 4.NP | 0.4162
267 | 4.NP | 0.0462
1051 | 1.NP | 0.0311801
1056 | 1.NP | 0.0261801
871 | 2.NP | 3.25
1243 | 1.NP | 0.063241
1174 | 1.NP | 0.0753746
1238 | 1.NP | 0.063241
1057 | 1.NP | 0.0162
1052 | 1.NP | 0.0162
1170 | 1.NP | 0.3162
267 | 4.NP | 0.2764
362 | 4.NP | 0.0971853
266 | 4.NP | 1.806
267 | 4.NP | 0.128609
417 | 4.NP | 0.132733
358 | 4.NP | 0.5164
374 | 4.NP | 0.0971853
1880 | 2.NP | 0.0232
375 | 4.NP | 0.5162
1233 | 1.NP | 0.063241
584 | 4.NP | 0.2764
461 | 4.NP | 0.00955364
380 | 4.NP | 0.0971853
454 | 4.NP | 0.4067
433 | 4.NP | 0.0700797
1234 | 1.NP | 0.0722
381 | 4.NP | 0.5162
411 | 4.NP | 0.0700797
453 | 4.NP | 0.00955364
438 | 4.NP | 0.0700797
386 | 4.NP | 0.5162
1169 | 1.NP | 0.0803746
412 | 4.NP | 0.5162
385 | 4.NP | 0.0973557
449 | 4.NP | 0.434809
434 | 4.NP | 0.5142
1244 | 1.NP | 0.0762
439 | 4.NP | 0.5142
462 | 4.NP | 0.4162
466 | 4.NP | 0.00955364
471 | 4.NP | 0.00955364
588 | 4.NP | 0.0790713
467 | 4.NP | 0.4162
472 | 4.NP | 0.4067
1239 | 1.NP | 0.0762
449 | 4.NP | 0.0097
1020 | 1.NP | 0.1164
584 | 4.NP | -0.000854141
583 | 4.NP | 0.337058
594 | 4.NP | 0.2762
600 | 4.NP | 0.2762
263 | 4.NP | 0.0442
1165 | 1.NP | 0.3162
584 | 4.NP | 0.871
1285 | 3.NP | 0.1264
1164 | 1.NP | 0.0753746
583 | 4.NP | 1.9464
875 | 2.NP | 0.673
584 | 4.NP | 0.868502
1520 | 4.NP | 0.127748
599 | 4.NP | 0.0790713
1512 | 4.NP | 0.127748
1513 | 4.NP | 0.3467
1175 | 1.NP | 0.3162
593 | 4.NP | 0.0790713
1760 | 4.NP | 0.0411636
1225 | 3.NP | 2.89616
966 | 4.NP | 0.360359
751 | 4.NP | 0.0042
701 | 4.NP | 1.45694
1021 | 3.NP | 0.0232
1521 | 4.NP | 0.3542
751 | 4.NP | 0.291633
694 | 4.NP | 0.173
885 | 1.NP | -0.0058
967 | 4.NP | 1.64014
1526 | 4.NP | 0.3542
694 | 4.NP | 0.3962
983 | 1.NP | 0.0641521
1894 | 3.NP | 0.0232
52 | 3.NP | 3.5232
880 | 1.NP | 0.0162
964 | 1.NP | 0.416905
961 | 1.NP | 1.54905
886 | 1.NP | 0.290932
1284 | 3.NP | 2.77556e-17
1817 | 3.NP | 0.1264
1019 | 1.NP | 0.0137052
995 | 1.NP | 0.0137052
1015 | 1.NP | 0
964 | 1.NP | 0.2664
887 | 1.NP | 1.6462
1802 | 3.NP | 3.69885
541 | 3.NP | 2.08167e-17
1812 | 3.NP | 0.0232
709 | 3.NP | 1.0964
1815 | 3.NP | 0.1264
710 | 3.NP | 0
1879 | 3.NP | 0.0232
729 | 3.NP | 0.3712
1880 | 3.NP | 0.2264
1816 | 3.NP | 0.3712
1808 | 3.NP | 0.37738
1828 | 3.NP | 0.0232
170 | 3.NP | 0.457819
728 | 3.NP | 0.1264
1818 | 3.NP | 0.3692
342 | 3.NP | 0.0042
668 | 3.NP | 0.00748223
844 | 3.NP | 0.1232
341 | 3.NP | 2.69643
844 | 3.NP | 0.0385855
907 | 3.NP | 0.251209
907 | 3.NP | 4.44089e-16
844 | 3.NP | 0.155497
668 | 3.NP | 0.621009
668 | 3.NP | 1.5737
811 | 3.NP | 1.5737
412 | 3.NP | 0.132951
632 | 3.NP | 14.8705
891 | 3.NP | 0.055
891 | 3.NP | 0.0042
412 | 3.NP | 0.306498
852 | 3.NP | 0.0421
324 | 3.NP | 2.51838
891 | 3.NP | 0.2782
412 | 3.NP | 0.3232
311 | 3.NP | 0.166125
311 | 3.NP | 0.4232
632 | 3.NP | 0.0246371
311 | 3.NP | 0.16008
305 | 3.NP | 0.394734
305 | 3.NP | 0.4232
305 | 3.NP | 0.16528
324 | 3.NP | 0.146668
1760 | 4.NP | 0.017
1531 | 4.NP | 0.3542
1760 | 4.NP | 0.0364118
1795 | 4.NP | 0.073
1525 | 4.NP | 0.127748
1530 | 4.NP | 0.127748
694 | 4.NP | 0.0464
745 | 4.NP | 0.1762
701 | 4.NP | 0.0042
756 | 4.NP | 0.1722
932 | 4.NP | 0.123
736 | 4.NP | 0.108806
940 | 4.NP | 0.133543
1013 | 1.NP | 0.291303
983 | 1.NP | 0.0164
1015 | 1.NP | 0.171127
1225 | 3.NP | 0.0092
971 | 1.NP | 0.0183042
1014 | 1.NP | 1.7964
1286 | 3.NP | 0.3712
887 | 1.NP | 0.2462
1012 | 1.NP | -0.00379852
512 | 4.NP | 0.135436
870 | 4.NP | 1.84349
849 | 4.NP | 0.0272277
871 | 4.NP | 0.324272
880 | 4.NP | 0.102911
842 | 4.NP | 0.221021
881 | 4.NP | 0.1762
881 | 4.NP | 0.4462
841 | 4.NP | 1.91917
515 | 4.NP | 0.135436
850 | 4.NP | 0.1762
850 | 4.NP | 0.3962
347 | 4.NP | 0.135606
478 | 4.NP | 0.135436
471 | 4.NP | 0.135606
339 | 4.NP | 0.135606
336 | 4.NP | 0.135606
473 | 4.NP | 0.135606
480 | 4.NP | 0.135436
870 | 1.NP | 0.0162
869 | 1.NP | 0.015178
344 | 4.NP | 0.135606
864 | 1.NP | 0.0782019
191 | 4.NP | 0.8532
232 | 4.NP | 0.0042
835 | 1.NP | 0.168817
234 | 4.NP | 0.8532
242 | 4.NP | 0.0042
150 | 4.NP | 0.8532
240 | 4.NP | 0.8532
865 | 1.NP | 0.1162
830 | 1.NP | 0.168817
168 | 4.NP | 0.8532
191 | 4.NP | 0.0042
907 | 1.NP | 1.8964
232 | 4.NP | 0.8532
238 | 4.NP | 0.0042
842 | 1.NP | 0.1067
823 | 1.NP | 0.0667
234 | 4.NP | 0.0042
111 | 2.NP | 0.563
2825 | 2.NP | 0.05
390 | 4.NP | 0.0971853
351 | 4.NP | 0.6462
350 | 4.NP | 0.631
351 | 4.NP | 0.0042
273 | 4.NP | 0.631
273 | 4.NP | 0.287856
273 | 4.NP | 0.671
855 | 4.NP | 1.9462
349 | 4.NP | 1.9462
330 | 4.NP | 0.780323
350 | 4.NP | 0.5164
350 | 4.NP | 0.6462
350 | 4.NP | 0.671
350 | 4.NP | 0.30072
767 | 4.NP | 0.1782
766 | 4.NP | 0.5162
652 | 4.NP | 1.12365
686 | 4.NP | 0.746201
65 | 4.NP | 1.24769
697 | 4.NP | -0.0153065
758 | 4.NP | 0
686 | 4.NP | 0.2764
852 | 4.NP | 0.0097
1781 | 4.NP | 0.157391
519 | 4.NP | 0.480073
647 | 4.NP | 0.289981
1780 | 4.NP | 1.873
786 | 4.NP | 0.1782
1728 | 4.NP | 0.934495
499 | 4.NP | 0.0092
785 | 4.NP | 1.9462
446 | 4.NP | 0.646
446 | 4.NP | 0.0097
785 | 4.NP | 0.4162
446 | 4.NP | 0.6462
498 | 4.NP | 3.47526
583 | 4.NP | 0.540545
518 | 4.NP | 2.77903e-15
583 | 4.NP | 0.0831165
1457 | 4.NP | 0.7052
1457 | 4.NP | 0.0097
836 | 1.NP | 0.1542
831 | 1.NP | 0.1542
189 | 4.NP | 0.8532
242 | 4.NP | 0.8532
236 | 4.NP | 0.0042
879 | 1.NP | 0.014079
908 | 1.NP | 0.646
236 | 4.NP | 0.8532
908 | 1.NP | 0.0097
522 | 3.NP | 0.1264
875 | 1.NP | 0.1162
523 | 3.NP | 0.3712
189 | 4.NP | 0.0042
874 | 1.NP | 0.0782019
814 | 1.NP | 2.80379e-07
238 | 4.NP | 0.8532
908 | 1.NP | 0.6462
150 | 4.NP | 0.0042
508 | 3.NP | 0.3712
1401 | 2.NP | 0.0232
168 | 4.NP | 0.0042
52 | 3.NP | 3.80815
908 | 1.NP | 0.450327
822 | 1.NP | 0.0738174
841 | 1.NP | 0.0782019
836 | 1.NP | -6.93889e-17
921 | 3.NP | 4.05558
240 | 4.NP | 0.0042
884 | 3.NP | 0.0419

# IfcPipeSegment: Fiber Basalt Plus (102)
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.0035 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-Fib-25; ModelLabel: Fiber Basalt Plus; Manufacturer: Ekoplastik
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.025 m; InnerDiameter: 0.018 m; OuterDiameter: 0.025 m
Name | In | Length (m)
1006 | 3.NP | 0.0147925
1006 | 3.NP | 0.0201312
1001 | 3.NP | 0.074
1344 | 2.NP | 0.392
871 | 2.NP | 0.17
1132 | 1.NP | -0.081
875 | 2.NP | 0.75
1091 | 1.NP | 0.727239
1133 | 1.NP | 0.117421
885 | 1.NP | 0
1091 | 1.NP | 0.627509
863 | 1.NP | 0
1135 | 1.NP | 0.0330639
1134 | 1.NP | 1.638
799 | 1.NP | -0.012
912 | 1.NP | 0.0055
884 | 1.NP | 2.34133
912 | 1.NP | 0.839543
800 | 1.NP | 0.188323
912 | 1.NP | 0.548926
911 | 1.NP | 1.688
803 | 1.NP | 1.22935
912 | 1.NP | 0.651321
869 | 1.NP | 0.356198
800 | 1.NP | 0.167868
869 | 1.NP | 2.31074
47 | 2.NP | 0.104687
1166 | 2.NP | 0.0580339
1199 | 2.NP | 0.0635
47 | 2.NP | 3.98017
46 | 2.NP | 0.221643
1166 | 2.NP | 0.0181
1341 | 3.NP | 0.672
577 | 3.NP | 4.05604
962 | 3.NP | 11.206
1007 | 1.NP | 0.536346
1008 | 1.NP | 0.069
977 | 1.NP | 0.069
577 | 3.NP | 3.619
1005 | 1.NP | 3.58155
976 | 1.NP | 0.354661
946 | 1.NP | 0.069
948 | 1.NP | 14.5176
947 | 1.NP | 3.76474
1404 | 2.NP | 0.038
1006 | 1.NP | 14.4123
1191 | 2.NP | 0.0295877
2815 | 2.NP | 10.5999
1191 | 2.NP | 3.96777
2815 | 2.NP | 1.42247e-16
1353 | 2.NP | 0.0952144
1344 | 2.NP | 1.84
1396 | 2.NP | 0.33525
1367 | 2.NP | 10.8378
2815 | 2.NP | 0.0125
368 | 2.NP | 0.207
1353 | 2.NP | 0.217
1344 | 2.NP | 0.0045
1396 | 2.NP | 0.42
886 | 1.NP | -0.001
886 | 1.NP | 1.28506
844 | 1.NP | 0.0809278
283 | 4.NP | 0.460391
283 | 4.NP | 0.508
843 | 1.NP | 0.0379997
884 | 1.NP | 0.147106
884 | 1.NP | 3.68065
875 | 2.NP | 1.42
287 | 4.NP | 0.0658797
283 | 4.NP | 0.641
266 | 4.NP | 0.033
283 | 4.NP | 0.644
883 | 1.NP | 0.219
1760 | 4.NP | 0.03
1805 | 3.NP | 0.037
840 | 1.NP | -0.00401211
668 | 3.NP | 11.1531
668 | 3.NP | 0.027
1457 | 4.NP | 0.425695
2 x 1457 | 4.NP | 0.704
1178 | 4.NP | 0.158586
1455 | 4.NP | 1.938
1178 | 4.NP | 2.26959
1012 | 3.NP | 0.0350383
1344 | 2.NP | 0.072
2815 | 2.NP | 0.0504735
758 | 4.NP | 0.667375
1689 | 4.NP | 1.13798e-15
1689 | 4.NP | 0.144655
1691 | 4.NP | 0.0055
1661 | 4.NP | 0
1690 | 4.NP | 0.663678
1689 | 4.NP | 0.0206376
583 | 4.NP | 0.05
583 | 4.NP | 3.318
1456 | 4.NP | 1.72824
1341 | 3.NP | 2.991
1341 | 3.NP | 4.1541
1001 | 3.NP | 4.26326e-14
1011 | 3.NP | 0.0648371
1001 | 3.NP | 0.055

# IfcPipeSegment: Fiber Basalt Plus (91)
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.0044 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-Fib-26; ModelLabel: Fiber Basalt Plus; Manufacturer: Ekoplastik
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.032 m; InnerDiameter: 0.0232 m; OuterDiameter: 0.032 m
Name | In | Length (m)
853 | 2.NP | 0.265002
868 | 2.NP | 0.128318
845 | 2.NP | 0.382794
857 | 2.NP | 1.287
856 | 2.NP | 0.027
846 | 2.NP | 5.02156
803 | 1.NP | 3.34258
226 | 3.NP | 0.207
803 | 1.NP | 0.0463057
634 | 2.NP | 3.9
6 | 2.NP | 0.517858
47 | 2.NP | 3.9349
47 | 2.NP | 0.025
946 | 4.NP | 0.0635
137 | 2.NP | 0.3975
946 | 4.NP | 0.219433
947 | 4.NP | 2.477
969 | 4.NP | 0.0635
947 | 4.NP | 0
454 | 2.NP | 0.64563
970 | 4.NP | 0.637
977 | 4.NP | 3.463
970 | 4.NP | 0.0145
969 | 4.NP | 0.182983
136 | 2.NP | 0.0825
60 | 2.NP | 1.422
47 | 2.NP | 0.240238
456 | 3.NP | 8.26662
455 | 3.NP | 3.38609
649 | 3.NP | 3.6135
463 | 3.NP | 0.0290974
464 | 3.NP | 0.0065
944 | 3.NP | 0.497847
945 | 3.NP | 1.80238
945 | 3.NP | 3.16931
936 | 3.NP | 0.265257
944 | 3.NP | 0.614
950 | 3.NP | 1.1725
1191 | 2.NP | 0.025
1191 | 2.NP | 0.045
938 | 3.NP | 0.0145
937 | 3.NP | 0.027
949 | 3.NP | 0.107935
938 | 3.NP | 0.583066
455 | 2.NP | 0.0055
907 | 2.NP | 0.423169
465 | 2.NP | 0.710141
906 | 2.NP | 0.0376315
453 | 2.NP | 0.0275
111 | 2.NP | 1.731
6 | 2.NP | 4.44089e-16
368 | 2.NP | 0.005
464 | 2.NP | 0.194175
59 | 2.NP | 0.457091
801 | 1.NP | 0.0580687
801 | 1.NP | 0.0989223
754 | 1.NP | 0.242019
791 | 1.NP | 0.478995
763 | 1.NP | 0.628418
792 | 1.NP | 0.9305
789 | 1.NP | 0.127
790 | 1.NP | 0.569901
795 | 1.NP | 0.001
593 | 1.NP | 0.984563
630 | 1.NP | -1.38778e-17
613 | 1.NP | 0.208387
630 | 1.NP | 0.223
613 | 1.NP | 1.9006
613 | 1.NP | 2.50005
802 | 1.NP | 0.0775
190 | 1.NP | 0.063
1326 | 1.NP | 8.2295
190 | 1.NP | 0.280695
1326 | 1.NP | 9.23236
195 | 1.NP | 0.298101
190 | 1.NP | 0.119789
190 | 1.NP | 0.22663
946 | 1.NP | 5.52447e-13
800 | 1.NP | 0.0635
5 | 2.NP | 0.123743
857 | 2.NP | 0.69912
455 | 2.NP | 1.722
533 | 4.NP | 3.313
111 | 2.NP | 0.052
111 | 2.NP | 1.416
910 | 2.NP | 2.817
892 | 2.NP | 3.90067
892 | 2.NP | 0.245837
533 | 4.NP | 0.366474
533 | 4.NP | 0.111229
533 | 4.NP | 0.0265

# IfcPipeSegment: Fiber Basalt Plus (24)
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.0055 m, layer 0.009 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EP-Fib-27; ModelLabel: Fiber Basalt Plus; Manufacturer: Ekoplastik
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.04 m; InnerDiameter: 0.029 m; OuterDiameter: 0.04 m
Name | In | Length (m)
797 | 2.NP | 0.507
797 | 2.NP | 3.307
926 | 3.NP | 3.207
926 | 3.NP | 0
743 | 1.NP | 0.357
803 | 1.NP | 22.7608
761 | 1.NP | 0.564478
802 | 1.NP | 2.03488
1006 | 1.NP | 0.0697278
810 | 1.NP | 0.014
724 | 1.NP | 0.0364717
747 | 1.NP | 0.864
811 | 1.NP | 4.5777
724 | 1.NP | 0.0543856
748 | 1.NP | 1.85678
1006 | 1.NP | 0.0839099
676 | 1.NP | 4.67347
675 | 1.NP | 0.02
677 | 1.NP | 0.930521
637 | 1.NP | 1.33227e-15
593 | 1.NP | 0.049
675 | 1.NP | 2.34593
637 | 1.NP | 1.362
637 | 1.NP | 1.405

# IfcPipeSegment: HT kanalizační potrubí DN 100 (252)
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.0027 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: HT12/0619; ModelLabel: HT kanalizační potrubí DN 100; Manufacturer: DDS
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.1 m; InnerDiameter: 0.1046 m; OuterDiameter: 0.11 m
Name | In | Length (m)
496 | Základy | 0.248593
371 | Základy | 1.24372
144 | 3.NP | 1.88886
216 | Základy | 1.3728
144 | 3.NP | 0.448137
192 | 3.NP | 0.0885709
360 | Základy | 1.08948
368 | Základy | 0.222574
372 | Základy | 0.295404
108 | Základy | 0
94 | Základy | 1.065
53 | Základy | 0.784755
144 | 3.NP | -0.0292019
373 | Základy | 0.263183
53 | Základy | 0.0178209
218 | Základy | 0.000025055
367 | Základy | 0.203208
217 | Základy | 0.33037
244 | Základy | 0.222858
251 | Základy | 0.233022
757 | 4.NP | 0.673042
246 | Základy | 1.41984
245 | Základy | 0.132575
128 | Základy | 0
1698 | Základy | 0
108 | Základy | 1.065
682 | 2.NP | 0.391974
916 | Základy | 3.55271e-15
587 | 2.NP | 0
1520 | Základy | 0.24385
372 | 4.NP | 0.00914411
1510 | Základy | 0.0312722
1501 | Základy | 1.28443
128 | Základy | 0.965
926 | Základy | 0.274805
916 | Základy | 1.3488
927 | Základy | 0.0630738
1504 | Základy | 1.29
731 | 2.NP | 0.0010375
606 | 2.NP | 0.0387998
587 | 2.NP | 0.594129
587 | 2.NP | 0.0727851
144 | 3.NP | 0.279399
162 | 3.NP | 0.0243163
993 | Základy | 0
306 | Základy | 0.295285
304 | Základy | 0.952026
305 | Základy | 0.21546
309 | Základy | 4.74135
310 | Základy | 0.175342
309 | Základy | 2.10065
305 | Základy | 2.07178
361 | Základy | 0.110707
990 | Základy | 3.54371e-32
156 | Základy | 0.509752
13 | Základy | 9.05317
152 | Základy | 0.599584
990 | Základy | 1.59
157 | Základy | 0.000853255
13 | Základy | 0.209787
731 | 2.NP | 2.77556e-17
13 | Základy | 1.74293
360 | Základy | 1.66306
1077 | 4.NP | -0.00455434
1076 | 4.NP | 0.101764
1078 | 4.NP | 0.0210454
1070 | 4.NP | 0.0000496461
1332 | 4.NP | 0.149939
1308 | 4.NP | 0.25
1332 | 4.NP | -0.0129394
784 | 2.NP | 0.330604
1075 | 4.NP | 1.05418
1075 | 4.NP | 0.776134
993 | Základy | 1.64
4 | Střecha | 0.25
6 | Střecha | 0.25
2 | Střecha | 3.33067e-16
155 | Základy | 1.24427
501 | Základy | 0.261209
445 | Základy | 1.52793
757 | 4.NP | 0.0660712
679 | 2.NP | 0.00393636
681 | 2.NP | 0.00399374
236 | 3.NP | 0.385547
483 | 2.NP | 0.525905
671 | 2.NP | -4.3715e-16
484 | 2.NP | 0.00399961
802 | 1.NP | 7.46527e-09
814 | 1.NP | 0.472582
482 | 2.NP | 0.0243945
680 | 2.NP | 0.54538
806 | 1.NP | 0.101404
824 | 1.NP | 2.55519
378 | 3.NP | 0.659724
1363 | 3.NP | 0.381661
376 | 3.NP | 0.166716
377 | 3.NP | 0.385379
1363 | 3.NP | 0.442246
1425 | 3.NP | 0.0588503
1363 | 3.NP | 2.77309
1426 | 3.NP | 0.000227985
671 | 2.NP | 0
682 | 2.NP | -1.38778e-17
467 | Základy | 0.643751
855 | 1.NP | 5.8368
463 | Základy | 0.273821
466 | Základy | 3.87552
462 | Základy | 1.45977
813 | 1.NP | 5.66178
517 | Základy | 0.180492
860 | 1.NP | -0.00865572
311 | Základy | 0.0000371144
823 | 1.NP | 0.190234
441 | Základy | 0.368043
375 | Základy | 0.28276
466 | Základy | 5.92319
861 | 1.NP | 0.00379026
956 | Základy | 0
376 | Základy | 0.138215
516 | Základy | 1.45748
442 | Základy | 0.236011
427 | 2.NP | 0.00000291079
1016 | 1.NP | 0.104545
427 | 2.NP | 2.52
1021 | 1.NP | 0.0998991
1022 | 1.NP | 0.00571947
988 | 1.NP | 0.0139332
1016 | 1.NP | 0.750962
1016 | 1.NP | 0.453047
987 | 1.NP | -0.0236845
986 | 1.NP | 0.03385
981 | 1.NP | 0.201021
1016 | 1.NP | 0.223276
818 | 1.NP | -0.00838257
819 | 1.NP | 0.135244
814 | 1.NP | 0.0101867
820 | 1.NP | 0.0101867
802 | 1.NP | 0.0962042
796 | 1.NP | 0.714366
813 | 1.NP | 0.117581
812 | 1.NP | -0.00838257
803 | 1.NP | 0.0101867
911 | 1.NP | -4.16334e-16
796 | 1.NP | 0.665138
912 | 1.NP | 0
801 | 1.NP | 0.104542
427 | 2.NP | 0.152809
664 | 1.NP | 0.260686
667 | 1.NP | 3.3
664 | 1.NP | 2.77894
664 | 1.NP | -0.0122141
664 | 1.NP | -0.00171237
576 | 1.NP | 0.566
574 | 1.NP | 0.679201
549 | 1.NP | 2.84873
549 | 1.NP | 0.233271
574 | 1.NP | 0
576 | 1.NP | 0
574 | 1.NP | 0.00179855
574 | 1.NP | 1.72198
574 | 1.NP | -0.001
576 | 1.NP | 0.181
574 | 1.NP | 0.031
427 | 2.NP | 0.497547
226 | 3.NP | 0.0000123797
1516 | Základy | 9.15934e-16
870 | 1.NP | 1.25
784 | 2.NP | 2.52
1022 | 1.NP | 0.0320861
872 | 1.NP | 1.25
899 | 1.NP | 0.169
504 | 4.NP | 0.02
543 | 4.NP | 0.0338501
504 | 4.NP | 0.181
545 | 4.NP | 0.0201491
544 | 4.NP | 0.0312724
794 | 1.NP | 0.096487
899 | 1.NP | 1.75999
504 | 4.NP | 0.063243
538 | 4.NP | 0.196963
504 | 4.NP | 0.429757
794 | 4.NP | 0.0180657
813 | 4.NP | 0.0412135
1001 | 1.NP | 0.062157
789 | 4.NP | 0.197605
811 | 4.NP | -0.00838257
795 | 4.NP | 0.0386694
825 | 4.NP | -0.00557234
826 | 4.NP | 0.00187062
827 | 4.NP | 0.0389984
812 | 4.NP | -0.0190748
899 | 1.NP | 0
795 | 1.NP | 0.00000984723
1516 | Základy | 1.12124
899 | 1.NP | 0.624
427 | 2.NP | 0.0679442
1501 | Základy | 8.67362e-16
682 | 2.NP | 0.0516622
1504 | Základy | 2.51215e-14
