Properties of the parts of a building model (IFC4), part 2 of 2

# IfcPipeSegment: HT kanalizační potrubí DN 100 (252)
Name | In | Length (m)
445 | Základy | 7.77156e-16
899 | 1.NP | 0.031
784 | 2.NP | 0.549396
497 | Základy | 0.158549
577 | 3.NP | 1.85975
577 | 3.NP | 0.588109
577 | 3.NP | 0.231718
322 | 3.NP | 0
577 | 3.NP | 0.0351737
577 | 3.NP | 0.477252
415 | 3.NP | 0.104153
235 | 3.NP | 0.153671
426 | 3.NP | 0.03125
517 | 3.NP | 0.536786
508 | 3.NP | 4.44089e-16
118 | 3.NP | 0.40834
508 | 3.NP | 0.372414
104 | 3.NP | 0.15006
104 | 3.NP | 0.0000121537
418 | 3.NP | 0
418 | 3.NP | 0.362241
104 | 3.NP | 0.030049
119 | 3.NP | 3.45575
226 | 3.NP | 0.37795
518 | 3.NP | 0.00195585
347 | 4.NP | -0.0815799
347 | 4.NP | 2.52
372 | 4.NP | 0.290145
347 | 4.NP | 0.656
101 | 4.NP | 1.87
347 | 4.NP | 0.17958
101 | 4.NP | 0.0541041
101 | 4.NP | 0.660768
326 | 4.NP | 0.674
326 | 4.NP | 2.52
101 | 4.NP | 0.109128
326 | 4.NP | 0.333
1354 | 4.NP | 0.0155788
1153 | 4.NP | 0.003807
1114 | 4.NP | 0.0249755
1114 | 4.NP | 1.05609
591 | 4.NP | 0.84672
1152 | 4.NP | -0.0170178
1115 | 4.NP | 0.0000718783
1354 | 4.NP | -0.0077147
1354 | 4.NP | 0.0161359
1154 | 4.NP | 0.0752764
591 | 4.NP | 0.0187804
863 | 4.NP | 0.0815
587 | 2.NP | 0.238871
144 | 3.NP | 0.597803
587 | 2.NP | 2.26421
500 | Základy | 1.41204

# IfcPipeSegment: HT kanalizační potrubí DN 125 (66)
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.0031 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: HT12/0719; ModelLabel: HT kanalizační potrubí DN 125; Manufacturer: DDS
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.125 m; InnerDiameter: 0.1188 m; OuterDiameter: 0.125 m
Name | In | Length (m)
430 | Základy | 0.113457
430 | Základy | 0.0102759
151 | Základy | 1.17757e-16
151 | Základy | 0.825746
1457 | 2.NP | 3.9
827 | 2.NP | 3.9
31 | 2.NP | 3.9
28 | 2.NP | 3.9
34 | 2.NP | 3.9
795 | Základy | 3.05593
5 | 3.NP | 3.375
805 | Základy | 0.987338
768 | Základy | 0
776 | Základy | 3.88578e-16
457 | Základy | 0.121296
495 | 4.NP | 0.25
442 | 4.NP | 3.75
492 | 4.NP | 0.25
144 | 3.NP | 0.375
145 | 3.NP | 0.0144105
5 | 4.NP | 3.9
8 | 4.NP | 3.9
11 | 4.NP | 3.9
857 | Střecha | 0.15
860 | Střecha | 0.15
2 | Střecha | 0.25
862 | Střecha | 0.25
864 | Střecha | 0.25
456 | Základy | 0.498239
776 | Základy | 0.825
767 | Základy | 0.109126
676 | Základy | 1.95025e-07
675 | Základy | 1.61066
80 | 3.NP | 1.38778e-17
22 | 3.NP | 3.9
148 | 3.NP | 3.3763
25 | 3.NP | 3.9
1448 | 3.NP | 3.9
80 | 3.NP | 0.375
20 | 3.NP | 3.9
1451 | 3.NP | 3.9
149 | 3.NP | 0.0281633
11 | 2.NP | 3.9
40 | 1.NP | 3.3
1460 | 1.NP | 3.3
37 | 1.NP | 3.3
43 | 1.NP | 3.3
1463 | 1.NP | 3.3
830 | 1.NP | 3.3
14 | 1.NP | 3.3
1454 | 2.NP | 3.9
602 | Základy | 0.97713
601 | Základy | 1.27361
665 | Základy | 2.42258
161 | 4.NP | 3.75
506 | 3.NP | -0.00700525
3571 | 3.NP | 0.07202
505 | 3.NP | 9.34431
117 | 3.NP | 0.001
3571 | 3.NP | 0.275202
426 | 3.NP | 0.413705
551 | Základy | 0.0000203579
766 | Základy | 0.0257462
551 | Základy | 0.663606
602 | Základy | 0.75302
768 | Základy | 0.64817

# IfcPipeSegment: HT kanalizační potrubí DN 150 (5)
In: Základy
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.0039 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: HT12/0819; ModelLabel: HT kanalizační potrubí DN 150; Manufacturer: DDS
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.15 m; InnerDiameter: 0.1522 m; OuterDiameter: 0.16 m
Name | Length (m)
251 | 0.0956551
1520 | 0.639969
755 | 4.57226
755 | 2.26546
1521 | 2.73369

# IfcPipeSegment: HT kanalizační potrubí DN 40 (16)
In: 1.NP
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.0018 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: HT12/0219; ModelLabel: HT kanalizační potrubí DN 40; Manufacturer: DDS
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.04 m; InnerDiameter: 0.0364 m; OuterDiameter: 0.04 m
Name | Length (m)
1022 | 0.601359
1021 | 0.1233
917 | 1.91086
808 | 0.205247
916 | 0.382142
1041 | 0.000320028
1040 | 0.0259979
832 | 0
1001 | 2.70027
901 | 14.0668
813 | 14.0204
832 | 0.140523
900 | 0.201496
899 | 0.350843
1000 | 0.500234
812 | 0.152164

# IfcPipeSegment: HT kanalizační potrubí DN 50 (221)
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.0018 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: HT12/0319; ModelLabel: HT kanalizační potrubí DN 50; Manufacturer: DDS
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.05 m; InnerDiameter: 0.0464 m; OuterDiameter: 0.05 m
Name | In | Length (m)
795 | 4.NP | 0.122596
376 | 3.NP | 0.137351
134 | 4.NP | 0.246461
135 | 4.NP | 0.025605
383 | 3.NP | 0.14992
785 | 4.NP | 0.153943
757 | 4.NP | 0.0324222
757 | 4.NP | 0.810369
1409 | 3.NP | 0.138089
784 | 4.NP | 0.173383
133 | 4.NP | 0.160714
779 | 4.NP | 0.625711
779 | 4.NP | 0.500584
220 | 3.NP | 0.385203
786 | 4.NP | 0.10112
1410 | 3.NP | 0.205156
663 | 2.NP | 0.000368434
658 | 2.NP | 0.0843507
199 | 3.NP | 0
743 | 3.NP | 0.371089
745 | 3.NP | 0.00238841
47 | 2.NP | 0.445084
1466 | 2.NP | 0.0841911
1473 | 2.NP | 0.149965
1470 | 2.NP | 0.282857
48 | 2.NP | 0.222981
60 | 2.NP | 0.14992
1471 | 2.NP | 4.03437e-07
1469 | 2.NP | 0.134278
73 | 2.NP | 0.0119047
61 | 2.NP | 0.0119691
463 | 2.NP | 0.601622
1539 | 4.NP | 0
1539 | 4.NP | 0.766815
1545 | 4.NP | 0.000108461
364 | 4.NP | 0.0000176283
357 | 4.NP | 0.00232721
363 | 4.NP | 0.194465
199 | 3.NP | 0.362637
358 | 4.NP | 1.68232
875 | 4.NP | 0.188997
879 | 4.NP | 0.000594118
881 | 4.NP | 0.0152836
882 | 4.NP | 0.0539914
875 | 4.NP | 4.4412e-16
880 | 4.NP | 0.0433083
744 | 3.NP | 0.0106776
1089 | 4.NP | 0.00608969
1090 | 4.NP | 0.000699564
1088 | 4.NP | -0.014034
606 | 2.NP | 4.6378
657 | 2.NP | 0.0709417
661 | 2.NP | 0.135623
665 | 2.NP | 0.14992
14 | 3.NP | 0.0861911
464 | 2.NP | 0.00018388
662 | 2.NP | 0.254839
211 | 3.NP | 0.445689
214 | 3.NP | 0.178376
238 | 3.NP | 0.149859
257 | 3.NP | 0.285055
256 | 3.NP | 0.135666
241 | 3.NP | 0.0706141
215 | 3.NP | 0.624469
263 | 3.NP | 0.149965
242 | 3.NP | 0.134191
216 | 3.NP | 0.000173898
1421 | 3.NP | 0.0671125
1420 | 3.NP | 0.0120736
481 | 2.NP | 0.0411757
494 | 2.NP | 0.151719
481 | 2.NP | 0
493 | 2.NP | 1.09699
495 | 2.NP | 0.00000395962
452 | 2.NP | -1.50227e-15
827 | 1.NP | 0.185887
794 | 1.NP | 0.0157755
828 | 1.NP | 0.0716799
884 | 1.NP | 0.185586
848 | 1.NP | 0.0206041
836 | 1.NP | 0.0206041
841 | 1.NP | 0.185559
885 | 1.NP | 0.0827304
842 | 1.NP | 0.0689742
1103 | 1.NP | 0.0801791
1111 | 1.NP | 0.014165
826 | 1.NP | 0.0999874
818 | 1.NP | 0.191016
1105 | 1.NP | 0.014165
1093 | 1.NP | 0.014165
815 | 1.NP | 0.0157755
851 | 1.NP | 0.63934
1104 | 1.NP | 0.344612
851 | 1.NP | 0.43948
1040 | 1.NP | 0.313957
1109 | 1.NP | 0.0628288
1039 | 1.NP | -0.00638217
1110 | 1.NP | 0.3591
1034 | 1.NP | 0.301856
1086 | 1.NP | 0.447235
1041 | 1.NP | 0.0351255
1033 | 1.NP | -0.00638217
1092 | 1.NP | 0.328823
1091 | 1.NP | 0.131027
1035 | 1.NP | 0.0351255
1005 | 1.NP | 0.00822574
1004 | 1.NP | 0.159593
1086 | 1.NP | 0.625714
897 | 1.NP | 0.190108
1003 | 1.NP | 0.13102
896 | 1.NP | 0.0628443
998 | 1.NP | 1.6984
898 | 1.NP | 0.0421346
997 | 1.NP | 0.0304152
880 | 1.NP | 0.0421418
878 | 1.NP | 0.131041
873 | 1.NP | 0.625714
873 | 1.NP | 0.444664
892 | 1.NP | 0.0471314
891 | 1.NP | 0.175522
879 | 1.NP | 0.159834
890 | 1.NP | 0.0801946
453 | 2.NP | 0.13631
1438 | 2.NP | 0.149965
454 | 2.NP | 0.285024
1465 | 2.NP | 0.0706141
585 | 4.NP | 0.067493
815 | 4.NP | 0.10112
583 | 4.NP | 0.13103
814 | 4.NP | 0.212387
809 | 4.NP | 0.10112
802 | 4.NP | 0.183881
584 | 4.NP | 0.100938
813 | 4.NP | 0.105245
807 | 4.NP | 0.105245
808 | 4.NP | 0.198384
803 | 4.NP | 0.10112
595 | 4.NP | 0.0801778
609 | 4.NP | 0.067493
602 | 4.NP | 0.130733
607 | 4.NP | 0.0628273
582 | 4.NP | -0.0175
582 | 4.NP | 0.57514
601 | 4.NP | 0.0801778
596 | 4.NP | 0.116731
582 | 4.NP | 0.625714
608 | 4.NP | 0.145227
603 | 4.NP | 0.067493
597 | 4.NP | 0.067493
489 | 4.NP | 0.000895725
490 | 4.NP | 0.30187
491 | 4.NP | 0.115989
73 | 4.NP | 0
492 | 4.NP | 0.0511713
21 | 3.NP | 0.00034392
29 | 3.NP | 0.149966
1430 | 2.NP | 0.0706141
322 | 3.NP | 0
123 | 3.NP | 0.322543
135 | 3.NP | 0.0075
123 | 3.NP | 9.66038e-07
308 | 3.NP | 6.32732e-12
577 | 3.NP | 1.59967e-07
357 | 3.NP | 0.0075
623 | 3.NP | 0.0175
577 | 3.NP | 0.332624
308 | 3.NP | 0.320583
1544 | 4.NP | 0.104632
15 | 3.NP | 0.137312
810 | 3.NP | 0.0287657
804 | 3.NP | 2.72005e-15
804 | 3.NP | 0.719716
811 | 3.NP | 0.0493516
809 | 3.NP | -0.00849097
797 | 4.NP | 0.101291
504 | 4.NP | 0.0535398
499 | 4.NP | 1.29161e-07
494 | 4.NP | 0.0506615
505 | 4.NP | 0.0506596
503 | 4.NP | -0.000239895
499 | 4.NP | 0.768355
493 | 4.NP | 0.0535306
462 | 4.NP | 0
431 | 4.NP | 0.0535398
432 | 4.NP | 0.05083
430 | 4.NP | -0.000240112
468 | 4.NP | 0.0535398
426 | 4.NP | 0
469 | 4.NP | 0.05083
492 | 4.NP | -0.000243935
483 | 4.NP | 0
13 | 3.NP | 0.0173005
467 | 4.NP | -0.000240112
483 | 4.NP | 0.768355
1431 | 2.NP | 0.0841911
462 | 4.NP | 0.768355
426 | 4.NP | 0.768355
300 | 4.NP | -0.00584866
289 | 4.NP | 0.00428585
287 | 4.NP | 0.685923
20 | 3.NP | 0.304933
287 | 4.NP | -0.0175
308 | 4.NP | 0.0507149
301 | 4.NP | 0.0300681
312 | 4.NP | -0.0205684
313 | 4.NP | 0.0761498
220 | 3.NP | 0.293151
267 | 3.NP | 0.00207813
375 | 3.NP | 0.0709417
306 | 4.NP | -0.0205684
307 | 4.NP | 0.053109
796 | 4.NP | 0.169684
288 | 4.NP | 0.0456927
314 | 4.NP | 0.0507149
302 | 4.NP | 0.0507149
452 | 4.NP | 1.67215
290 | 4.NP | 0.0507149
453 | 4.NP | 0.173575
455 | 4.NP | 0.0220375
454 | 4.NP | 0.30499
801 | 4.NP | 0.105245

# IfcPipeSegment: HT kanalizační potrubí DN 70 (85)
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.0018 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: HT12/0419; ModelLabel: HT kanalizační potrubí DN 70; Manufacturer: DDS
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.07 m; InnerDiameter: 0.0712 m; OuterDiameter: 0.0748 m
Name | In | Length (m)
94 | Základy | 0.625
53 | Základy | 0.625
108 | Základy | 0.625
779 | 4.NP | 0.57214
779 | 4.NP | 0.098886
779 | 4.NP | 0.597145
128 | Základy | 0.625
748 | 2.NP | 0.153987
747 | 2.NP | 2.27519
875 | 4.NP | 0.0175
1120 | 4.NP | 0.25
86 | Základy | -4.44089e-16
1335 | 4.NP | 2.77556e-17
1346 | 4.NP | 4.11946
1335 | 4.NP | 0.008
1347 | 4.NP | 0.587403
2081 | 4.NP | 0.000378662
1348 | 4.NP | 8.92192e-08
2125 | 4.NP | 0.00715
2080 | 4.NP | 0.307646
2242 | 4.NP | 0.294794
2079 | 4.NP | 2.65595
2125 | 4.NP | -0.00000840084
2026 | 4.NP | 0.04116
2241 | 4.NP | 0.106936
2076 | 4.NP | 0.293908
2197 | 4.NP | 0.0643411
2026 | 4.NP | -0.00000840084
779 | 4.NP | 0.0125528
400 | 3.NP | -0.00000840084
400 | 3.NP | 0.05882
472 | 3.NP | 0.64498
473 | 3.NP | 1.8029
1123 | 3.NP | 0.0555221
1304 | 3.NP | 0.0404039
1123 | 3.NP | 0
1425 | 3.NP | 0.059473
851 | 1.NP | 0.370163
827 | 1.NP | 0.047561
852 | 1.NP | 2.06117
851 | 1.NP | 0.0969567
851 | 1.NP | 0.581373
1086 | 1.NP | 0.0809048
1085 | 1.NP | 0.0648456
1086 | 1.NP | 0.230843
873 | 1.NP | 0.0834755
872 | 1.NP | -2.42861e-16
873 | 1.NP | 0.165297
50 | 1.NP | 0.25
91 | 1.NP | 0.25
85 | 1.NP | 0.25
88 | 1.NP | 0.25
934 | 1.NP | 0.00140898
944 | 1.NP | 0.00000880865
582 | 4.NP | 0.092975
577 | 4.NP | 0.0947001
582 | 4.NP | 0.54564
943 | 1.NP | 0.0517611
358 | 3.NP | 0.142209
412 | 3.NP | 3.592
793 | 3.NP | 1.50736
136 | 3.NP | 0.10733
359 | 3.NP | 0.00491735
135 | 3.NP | 0.262427
702 | 3.NP | 0.0242015
793 | 3.NP | 0.406434
776 | 3.NP | 2.83989
193 | 3.NP | 0
663 | 3.NP | 0
137 | 3.NP | 0.00503768
411 | 3.NP | 0.326948
560 | 3.NP | 2.11683
623 | 3.NP | 0.188893
621 | 3.NP | -0.0049694
415 | 3.NP | 3.68596
417 | 3.NP | 4.04216
416 | 3.NP | 0.207823
622 | 3.NP | 0.1206
1395 | 3.NP | 3.55358
1394 | 3.NP | 0.299988
287 | 4.NP | 0.605849
287 | 4.NP | 0.632349
1245 | 4.NP | 0.231055
439 | 4.NP | 0.408312
357 | 3.NP | 0.181718

# IfcPipeSegment: KG kanalizační potrubí DN 150 (6)
In: Základy
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.0039 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: KG12/0819; ModelLabel: KG kanalizační potrubí DN 150; Manufacturer: DDS
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.15 m; InnerDiameter: 0.1522 m; OuterDiameter: 0.16 m
Name | Length (m)
176 | 2.98244
176 | 2.54878
176 | 11.2893
176 | 5.32013
176 | 0.0000500761
176 | 6.4909

# IfcSanitaryTerminal: Keramický pisoár (6)
Type - PredefinedType: URINAL
Type - Pset_ManufacturerTypeInformation - ArticleNumber: UR001; ModelLabel: Keramický pisoár; Manufacturer: DDS
Name | In
2 | 1.NP
1 | 1.NP
1 | 4.NP
4 | 4.NP
2 | 4.NP
3 | 4.NP

# IfcSanitaryTerminal: Kuchyňský dřez, 100x50 cm, s odkapávačem, 12
In: 1.NP
Type - PredefinedType: SINK
Type - Pset_ManufacturerTypeInformation - ArticleNumber: DCN100; ModelLabel: Kuchyňský dřez, 100x50 cm, s odkapávačem; Manufacturer: DDS

# IfcSanitaryTerminal: Stojící WC s horní nádržkou (2)
Type - PredefinedType: TOILETPAN
Type - Pset_ManufacturerTypeInformation - ArticleNumber: WC-160417-037; ModelLabel: Stojící WC s horní nádržkou; Manufacturer: DDS
Type - Pset_SanitaryTerminalTypeToiletPan - ToiletType: CLOSECOUPLED
Name | In
5 | 1.NP
1 | 4.NP

# IfcSanitaryTerminal: Umývadlo 45x30 cm, 17
In: 4.NP
Type - PredefinedType: SINK
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SI-240723101519; ModelLabel: Umývadlo 45x30 cm; Manufacturer: DDS

# IfcSanitaryTerminal: Umývadlo 55x45 cm (22)
Type - PredefinedType: SINK
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SI-240723101319; ModelLabel: Umývadlo 55x45 cm; Manufacturer: DDS
Name | In
2 | 1.NP
1 | 1.NP
9 | 1.NP
7 | 1.NP
3 | 1.NP
8 | 1.NP
11 | 1.NP
10 | 1.NP
6 | 1.NP
5 | 1.NP
4 | 1.NP
12 | 4.NP
15 | 4.NP
14 | 4.NP
16 | 4.NP
10 | 4.NP
13 | 4.NP
11 | 4.NP
25 | 4.NP
9 | 4.NP
8 | 4.NP
7 | 4.NP

# IfcSanitaryTerminal: Umývadlo 60x50 cm, 23
In: 3.NP
Type - PredefinedType: SINK
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BAN55/60; ModelLabel: Umývadlo 60x50 cm; Manufacturer: DDS

# IfcSanitaryTerminal: Umývadlo 75x44 cm (13)
Type - PredefinedType: SINK
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SI-240723101105; ModelLabel: Umývadlo 75x44 cm; Manufacturer: DDS
Name | In
1 | 4.NP
2 | 4.NP
27 | 2.NP
21 | 3.NP
22 | 3.NP
19 | 3.NP
20 | 3.NP
4 | 4.NP
24 | 2.NP
25 | 2.NP
26 | 2.NP
3 | 4.NP
5 | 4.NP

# IfcSanitaryTerminal: Závěsné WC s hlubokým splachováním a vestavnou nádržkou (9)
Type - PredefinedType: TOILETPAN
Type - Pset_ManufacturerTypeInformation - ArticleNumber: WC-160417-007; ModelLabel: Závěsné WC s hlubokým splachováním a vestavnou nádržkou; Manufacturer: DDS
Type - Pset_SanitaryTerminalTypeToiletPan - ToiletType: CLOSECOUPLED
Name | In
3 | 1.NP
2 | 1.NP
4 | 1.NP
1 | 1.NP
7 | 4.NP
5 | 4.NP
6 | 4.NP
4 | 4.NP
8 | 4.NP

# IfcSanitaryTerminal: Závěsný bidet typ I (2)
In: 4.NP
Type - PredefinedType: SINK
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SI-160404-022; ModelLabel: Závěsný bidet typ I; Manufacturer: DDS
Name
26
24

# IfcValve: ATUTOMATICKY VYVAŽOVACÍ VENTIL (2)
In: 2.NP
Type - Pset_ManufacturerTypeInformation - ArticleNumber: VA-170823183604; ModelLabel: ATUTOMATICKY VYVAŽOVACÍ VENTIL; Manufacturer: DDS

# IfcValve: Kulový ventil, mosaz, s rukojetí 1 1/4, plný průtok, přímý, -13
In: 2.NP
Type - Pset_ManufacturerTypeInformation - ArticleNumber: UB18/07; ModelLabel: Kulový ventil, mosaz, s rukojetí 1 1/4, plný průtok, přímý; Manufacturer: DDS

# IfcValve: Kulový ventil, mosaz, s rukojetí 1", plný průtok, přímý (25)
Type - Pset_ManufacturerTypeInformation - ArticleNumber: UB18/06; ModelLabel: Kulový ventil, mosaz, s rukojetí 1", plný průtok, přímý; Manufacturer: DDS
Name | In
3 x -13 | 3.NP
2 x -19 | 3.NP
5 x -15 | 3.NP
2 x -22 | 4.NP
4 x -12 | 2.NP
2 x -20 | 3.NP
-13 | 2.NP
-11 | 2.NP
-28 | 4.NP
-27 | 4.NP
-25 | 4.NP
-24 | 4.NP
-22 | 3.NP

# IfcValve: Kulový ventil, nerezové pouzdro PN 40 DN 25 1" s rukojetí (14)
In: 1.NP
Type - Pset_ManufacturerTypeInformation - ArticleNumber: UB50/06; ModelLabel: Kulový ventil, nerezové pouzdro PN 40 DN 25 1" s rukojetí; Manufacturer: DDS
Name
5 x 
7
2 x 2
5 x 1
4

# IfcValve: OCHRANNÁ JENDOTKA EA, DN32
In: 1.NP
Type - Pset_ManufacturerTypeInformation - ArticleNumber: VA-170823180436; ModelLabel: OCHRANNÁ JENDOTKA EA, DN32; Manufacturer: DDS

# IfcValve: Odvzdušňovací ventil DN 100 (2)
In: 4.NP
Type - PredefinedType: AIRRELEASE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: E1-20120102-004; ModelLabel: Odvzdušňovací ventil DN 100; Manufacturer: DDS
Name
406
368

# IfcValve: Odvzdušňovací ventil DN 50, 310
In: 1.NP
Type - PredefinedType: AIRRELEASE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: E1-20120102-001; ModelLabel: Odvzdušňovací ventil DN 50; Manufacturer: DDS

# IfcValve: Střešní odvzdušňovací ventil DN 100 (3)
In: Střecha
Type - PredefinedType: AIRRELEASE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: E1-20120102-006; ModelLabel: Střešní odvzdušňovací ventil DN 100; Manufacturer: DDS
Name
272
270
271
